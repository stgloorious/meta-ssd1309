FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-enable-jtag.patch"
